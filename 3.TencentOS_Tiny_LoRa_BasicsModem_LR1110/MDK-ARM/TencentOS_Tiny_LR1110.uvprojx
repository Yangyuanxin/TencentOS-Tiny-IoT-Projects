# Keil uVision project TencentOS_Tiny_LR1110.uvprojx, settings and files
target TencentOS_Tiny (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32L431RCTx STMicroelectronics
  pack: Keil.STM32L4xx_DFP.2.0.0
  cpu: IRAM(0x20000000,0x0000C000) IRAM2(0x10000000,0x00004000) IROM(0x08000000,0x00040000) CPUTYPE("Cortex-M4") FPU2 DSP CLOCK(12000000) ELITTLE
  output: TencentOS_Tiny_LR1110
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: STM32L431xx,USE_HAL_DRIVER,HYBRID_CN470_MONO_CHANNEL,LR1110,LR1110_TRANSCEIVER,_GNSS_SNIFF_ENABLE,REGION_CN_470_RP_1_0,CHINA_RP_1_DEMO
  c include: ..\lr1110_driver\src;..\user_app\mcu_drivers\cmsis\Core\Include;..\user_app\mcu_drivers\cmsis\Device\ST\STM32L4xx\Include;..\user_app\mcu_drivers\STM32L4xx_HAL_Driver\Inc;..\user_app\mcu_drivers\STM32L4xx_HAL_Driver\Inc\Legacy;..\smtc_modem_hal;..\user_app\smtc_modem_hal;..\user_app;..\user_app\mcu_drivers\core;..\user_app\modem_config;..\user_app\smtc_hal_l4;..\user_app\main_examples\geolocation_utilities;..\user_app\radio_hal;..\smtc_modem_core\modem_supervisor;..\smtc_modem_core\device_management;..\smtc_modem_core\modem_services;..\smtc_modem_core\lorawan_api;..\smtc_modem_services\headers;..\smtc_modem_services\src;..\smtc_modem_services\src\stream;..\smtc_modem_services\src\file_upload;..\smtc_modem_services\src\alc_sync;..\smtc_modem_services;..\smtc_modem_api;..\smtc_ral\src;..\smtc_ralf\src;..\lr1mac;..\lr1mac\src;..\lr1mac\src\services;..\lr1mac\src\lr1mac_class_c;..\radio_planner\src;..\smtc_crypto\src;..\lr1mac\src\smtc_real\src;..\TencentOS-tiny\arch\arm\arm-v7m\common\include;..\TencentOS-tiny\arch\arm\arm-v7m\cortex-m4\armcc;..\TencentOS-tiny\kernel\core\include;..\TencentOS-tiny\kernel\pm\include;..\TencentOS-tiny\osal\cmsis_os;..\TencentOS-tiny\TOS_CONFIG
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x10000
  memory RVCT10: RAM 0x10000000 size 0x4000
  group Startup
    ./: startup_stm32l431xx.s
  group smtc_modem_services
    ../smtc_modem_services/src/almanac_update/: almanac_update.c
    ../smtc_modem_services/src/stream/: rose.c stream.c
    ../smtc_modem_services/src/alc_sync/: alc_sync.c
    ../smtc_modem_services/src/file_upload/: file_upload.c
  group lr1110_driver
    ../lr1110_driver/src/: lr1110_bootloader.c lr1110_crypto_engine.c lr1110_driver_version.c lr1110_gnss.c lr1110_radio.c lr1110_regmem.c lr1110_system.c lr1110_wifi.c
  group smtc_ral
    ../smtc_ral/src/: ral_lr1110.c
  group smtc_ralf
    ../smtc_ralf/src/: ralf_lr1110.c
  group user_app
    ../user_app/: git_version.c
    ../user_app/main_examples/geolocation_utilities/: gnss.c wifi_scan.c
    ../user_app/main_examples/: main.c
  group user_app/lr1110
    ../user_app/radio_hal/: lr1110_hal.c ral_lr1110_bsp.c
  group user_app/mcu_drivers
    ../user_app/mcu_drivers/STM32L4xx_HAL_Driver/Src/: stm32l4xx_hal.c stm32l4xx_hal_adc.c stm32l4xx_hal_adc_ex.c stm32l4xx_hal_cortex.c stm32l4xx_hal_dma.c stm32l4xx_hal_flash.c stm32l4xx_hal_flash_ex.c stm32l4xx_hal_flash_ramfunc.c stm32l4xx_hal_gpio.c stm32l4xx_hal_i2c.c stm32l4xx_hal_i2c_ex.c stm32l4xx_hal_iwdg.c stm32l4xx_hal_lptim.c stm32l4xx_hal_pwr.c stm32l4xx_hal_pwr_ex.c stm32l4xx_hal_rcc.c stm32l4xx_hal_rcc_ex.c stm32l4xx_hal_rng.c stm32l4xx_hal_rtc.c stm32l4xx_hal_rtc_ex.c stm32l4xx_hal_spi.c stm32l4xx_hal_tim.c stm32l4xx_hal_tim_ex.c stm32l4xx_hal_usart.c stm32l4xx_hal_usart_ex.c stm32l4xx_hal_wwdg.c stm32l4xx_hal_uart.c stm32l4xx_hal_uart_ex.c
    ../user_app/mcu_drivers/core/: system_stm32l4xx.c
  group user_app/smtc_hal_l4/
    ../user_app/smtc_hal_l4/: smtc_hal_adc.c smtc_hal_flash.c smtc_hal_gpio.c smtc_hal_lp_timer.c smtc_hal_mcu.c smtc_hal_rng.c smtc_hal_rtc.c smtc_hal_spi.c smtc_hal_trace.c smtc_hal_uart.c smtc_hal_watchdog.c
  group user_app/smtc_modem_ha
    ../user_app/smtc_modem_hal/: smtc_modem_hal.c
  group smtc_modem_core
    ../smtc_modem_core/lorawan_api/: lorawan_api.c
    ../smtc_modem_core/device_management/: dm_downlink.c modem_context.c
    ../smtc_modem_core/modem_core/: smtc_modem.c smtc_modem_test.c
    ../smtc_modem_core/modem_services/: fifo_ctrl.c modem_utilities.c smtc_modem_services_hal.c
    ../smtc_modem_core/modem_supervisor/: modem_supervisor.c
  group lr1mac
    ../lr1mac/src/: lr1_stack_mac_layer.c lr1mac_core.c lr1mac_utilities.c
    ../lr1mac/src/smtc_real/src/: smtc_real.c region_cn_470_rp_1_0.c
    ../lr1mac/src/services/: smtc_duty_cycle.c smtc_lbt.c
    ../lr1mac/src/lr1mac_class_c/: lr1mac_class_c.c
  group smtc_crypto
    ../smtc_crypto/src/: aes.c cmac.c smtc_crypto.c
  group radio_planner
    ../radio_planner/src/: radio_planner.c radio_planner_hal.c
  group tos/arch
    ../TencentOS-tiny/arch/arm/arm-v7m/common/: tos_cpu.c
    ../TencentOS-tiny/arch/arm/arm-v7m/cortex-m4/armcc/: port_c.c port_s.S
  group tos/kernel
    ../TencentOS-tiny/kernel/core/: tos_barrier.c tos_binary_heap.c tos_bitmap.c tos_char_fifo.c tos_completion.c tos_countdownlatch.c tos_event.c tos_global.c tos_mail_queue.c tos_message_queue.c tos_mmblk.c tos_mmheap.c tos_mutex.c tos_pend.c tos_priority_mail_queue.c tos_priority_message_queue.c tos_priority_queue.c tos_ring_queue.c tos_robin.c tos_rwlock.c tos_sched.c tos_sem.c tos_stopwatch.c tos_sys.c tos_task.c tos_tick.c tos_time.c tos_timer.c
software components: CMSIS:CORE 5.4.0
