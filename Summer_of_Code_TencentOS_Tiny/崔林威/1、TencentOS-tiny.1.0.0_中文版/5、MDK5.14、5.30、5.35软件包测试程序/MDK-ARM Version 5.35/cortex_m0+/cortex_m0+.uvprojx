# Keil uVision project cortex_m0+.uvprojx, settings and files
target Target 1 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: ARMCM0P ARM
  pack: ARM.CMSIS.5.7.0
  cpu: IRAM(0x20000000,0x00020000) IROM(0x00000000,0x00040000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ESEL ELITTLE
  output: cortex_m0+
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
software components: CMSIS:CORE 5.4.0, Device:Startup 1.2.2, TencentOS tiny:arch:arch 1.0.0, TencentOS tiny:cmsis_os:cmsis_os 1.0.0, TencentOS tiny:example:helloworld_main 1.0.0, TencentOS tiny:example:mcu_it.c 1.0.0, TencentOS tiny:example:mcu_platform.h 1.0.0, TencentOS tiny:kernel:core 1.0.0, TencentOS tiny:kernel:hal 1.0.0, TencentOS tiny:kernel:tos_config 1.0.0
