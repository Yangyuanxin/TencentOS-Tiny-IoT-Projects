# Keil uVision project stm32f103c8.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: stm32f103c8
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
software components: CMSIS:CORE 5.4.0, Device:Startup 1.0.0, TencentOS tiny:arch:arch 1.0.0, TencentOS tiny:cmsis_os:cmsis_os 1.0.0, TencentOS tiny:example:helloworld_main 1.0.0, TencentOS tiny:example:mcu_it.c 1.0.0, TencentOS tiny:example:mcu_platform.h 1.0.0, TencentOS tiny:kernel:core 1.0.0, TencentOS tiny:kernel:hal 1.0.0, TencentOS tiny:kernel:tos_config 1.0.0
