# Keil uVision project stm32f767igt.uvprojx, settings and files
target Target 1 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F767IGTx STMicroelectronics
  pack: Keil.STM32F7xx_DFP.2.14.0
  cpu: IRAM(0x20020000,0x60000) IRAM2(0x20000000,0x20000) IROM(0x08000000,0x100000) IROM2(0x00200000,0x100000) CPUTYPE("Cortex-M7") FPU3(DFPU) CLOCK(12000000) ELITTLE
  output: stm32f767igt
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT5: ROM 0x200000 size 0x100000
  memory RVCT9: RAM 0x20020000 size 0x60000
  memory RVCT10: RAM 0x20000000 size 0x20000
software components: CMSIS:CORE 5.4.0, Device:Startup 1.2.5, TencentOS tiny:arch:arch 1.0.0, TencentOS tiny:cmsis_os:cmsis_os 1.0.0, TencentOS tiny:example:helloworld_main 1.0.0, TencentOS tiny:example:mcu_it.c 1.0.0, TencentOS tiny:example:mcu_platform.h 1.0.0, TencentOS tiny:kernel:core 1.0.0, TencentOS tiny:kernel:hal 1.0.0, TencentOS tiny:kernel:tos_config 1.0.0
