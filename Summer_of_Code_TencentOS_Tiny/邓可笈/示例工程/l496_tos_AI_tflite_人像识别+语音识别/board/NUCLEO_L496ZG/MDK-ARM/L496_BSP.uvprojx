# Keil uVision project L496_BSP.uvprojx, settings and files
target L496_BSP (6140000::V6.14::ARMCLANG)
  device: STM32L496ZGTx STMicroelectronics
  pack: Keil.STM32L4xx_DFP.2.5.0
  cpu: IRAM(0x20000000-0x2004FFFF) IROM(0x8000000-0x80FFFFF)  CLOCK(8000000) FPU2 CPUTYPE("Cortex-M4")
  output: L496_BSP +hex
  c flags: Optim=7 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: USE_HAL_DRIVER,STM32L496xx
  c include: ../Core/Inc;../Drivers/STM32L4xx_HAL_Driver/Inc;../Drivers/STM32L4xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32L4xx/Include;..\..\..\arch\arm\arm-v7m\common\include;..\..\..\arch\arm\arm-v7m\cortex-m4\armcc;..\..\..\kernel\core\include;..\..\..\kernel\pm\include;..\..\..\osal\cmsis_os;..\TOS_CONFIG;..\Drivers\CMSIS\Include;..\Core\HARDWARE;..\Core\HARDWARE\LCD\Inc;..\Core\HARDWARE\OV2640;.;.\third_party\flatbuffers\include;.\third_party\gemmlowp;.\third_party\kissfft;.\third_party\ruy;.\tensorflow\lite\micro\tools\make\downloads;.\tensorflow\lite\micro\examples\micro_speech\micro_features;.\tensorflow\lite\micro\testing;.\tensorflow\lite\micro\examples\micro_speech
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x50000
  group Application/MDK-ARM
    ./: startup_stm32l496xx.s
  group Application/User/Core
    ../Core/Src/: delay.c sys.c gpio.c dcmi.c dma.c i2c.c usart.c spi.c tim.c stm32l4xx_it.c stm32l4xx_hal_msp.c mcu_init.c regarget.c main.c
  group Drivers/STM32L4xx_HAL_Driver
    ../Drivers/STM32L4xx_HAL_Driver/Src/: stm32l4xx_hal_dcmi.c stm32l4xx_hal.c stm32l4xx_hal_i2c.c stm32l4xx_hal_i2c_ex.c stm32l4xx_hal_rcc.c stm32l4xx_hal_rcc_ex.c stm32l4xx_hal_flash.c stm32l4xx_hal_flash_ex.c stm32l4xx_hal_flash_ramfunc.c stm32l4xx_hal_gpio.c stm32l4xx_hal_dma.c stm32l4xx_hal_dma_ex.c stm32l4xx_hal_pwr.c stm32l4xx_hal_pwr_ex.c stm32l4xx_hal_cortex.c stm32l4xx_hal_exti.c stm32l4xx_hal_uart.c stm32l4xx_hal_uart_ex.c stm32l4xx_hal_spi.c stm32l4xx_hal_spi_ex.c stm32l4xx_hal_tim.c stm32l4xx_hal_tim_ex.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32l4xx.c
  group tos/arch
    ../../../arch/arm/arm-v7m/common/: tos_cpu.c
    ../../../arch/arm/arm-v7m/cortex-m4/armcc/: port_c.c port_s.S
  group tos/kernel
    ../../../kernel/core/: tos_barrier.c tos_binary_heap.c tos_bitmap.c tos_char_fifo.c tos_completion.c tos_countdownlatch.c tos_event.c tos_global.c tos_mail_queue.c tos_message_queue.c tos_mmblk.c tos_mmheap.c tos_mutex.c tos_pend.c tos_priority_mail_queue.c tos_priority_message_queue.c tos_priority_queue.c tos_ring_queue.c tos_robin.c tos_rwlock.c tos_sched.c tos_sem.c tos_stopwatch.c tos_sys.c tos_task.c tos_tick.c tos_time.c tos_timer.c
  group tos/cmsis_os
    ../../../osal/cmsis_os/: cmsis_os.c
  group Drivers/HARDWARE/Camera
    ../Core/HARDWARE/OV2640/: ov2640.c sccb.c
  group Drivers/HARDWARE/LCD
    ../Core/HARDWARE/LCD/Src/: DEV_Config.c LCD_2inch4.c
  group tensorflow/lite/c
    ./tensorflow/lite/c/: common.c
  group tensorflow/lite/core
    ./tensorflow/lite/core/api/: error_reporter.cc flatbuffer_conversions.cc op_resolver.cc tensor_utils.cc
  group tensorflow/lite/kernel
    ./tensorflow/lite/kernels/: kernel_util.cc
    ./tensorflow/lite/kernels/internal/: quantization_util.cc
  group tensorflow/lite/micro/
    ./tensorflow/lite/micro/: all_ops_resolver.cc debug_log.cc memory_helpers.cc micro_allocator.cc micro_error_reporter.cc micro_interpreter.cc micro_optional_debug_tools.cc micro_profiler.cc micro_string.cc micro_time.cc micro_utils.cc recording_micro_allocator.cc recording_simple_memory_allocator.cc simple_memory_allocator.cc test_helpers.cc
  group tensorflow/lite/micro/example
    ./tensorflow/lite/micro/examples/person_detection_experimental/: detection_responder.cc image_provider.cc main_functions.cc model_settings.cc
    ./tensorflow/lite/micro/tools/make/downloads/person_model_int8/: no_person_image_data.cc person_image_data.cc person_detect_model_data.cc
  group tensorflow/lite/micro/kernel
    ./tensorflow/lite/micro/kernels/cmsis-nn/: add.cc conv.cc depthwise_conv.cc fully_connected.cc mul.cc pooling.cc softmax.cc
    ./tensorflow/lite/micro/kernels/: activations.cc arg_min_max.cc ceil.cc circular_buffer.cc comparisons.cc concatenation.cc dequantize.cc elementwise.cc ethosu.cc floor.cc hard_swish.cc kernel_runner.cc kernel_util.cc l2norm.cc logical.cc logistic.cc maximum_minimum.cc neg.cc pack.cc pad.cc prelu.cc quantize.cc reduce.cc reshape.cc resize_nearest_neighbor.cc round.cc split.cc strided_slice.cc sub.cc svdf.cc tanh.cc unpack.cc
  group tensorflow/lite/micro/memory
    ./tensorflow/lite/micro/memory_planner/: greedy_memory_planner.cc linear_memory_planner.cc
  group tensorflow/lite/micro/testing
    ./tensorflow/lite/micro/testing/: test_conv_model.cc test_utils.cc
  group tensorflow/lite/micro/tools
    ./tensorflow/lite/micro/tools/make/downloads/cmsis/CMSIS/NN/Source/ActivationFunctions/: arm_nn_activations_q7.c arm_nn_activations_q15.c arm_relu_q7.c arm_relu_q15.c arm_relu6_s8.c
    ./tensorflow/lite/micro/tools/make/downloads/cmsis/CMSIS/NN/Source/BasicMathFunctions/: arm_elementwise_add_s8.c arm_elementwise_mul_s8.c
    ./tensorflow/lite/micro/tools/make/downloads/cmsis/CMSIS/NN/Source/ConcatenationFunctions/: arm_concatenation_s8_w.c arm_concatenation_s8_x.c arm_concatenation_s8_y.c arm_concatenation_s8_z.c
    ./tensorflow/lite/micro/tools/make/downloads/cmsis/CMSIS/NN/Source/ConvolutionFunctions/: arm_convolve_1_x_n_s8.c arm_convolve_1x1_HWC_q7_fast_nonsquare.c arm_convolve_1x1_s8_fast.c arm_convolve_HWC_q7_basic.c arm_convolve_HWC_q7_basic_nonsquare.c arm_convolve_HWC_q7_fast.c arm_convolve_HWC_q7_fast_nonsquare.c arm_convolve_HWC_q7_RGB.c arm_convolve_HWC_q15_basic.c arm_convolve_HWC_q15_fast.c arm_convolve_HWC_q15_fast_nonsquare.c arm_convolve_s8.c arm_convolve_wrapper_s8.c arm_depthwise_conv_3x3_s8.c arm_depthwise_conv_s8.c arm_depthwise_conv_s8_opt.c arm_depthwise_conv_u8_basic_ver1.c arm_depthwise_conv_wrapper_s8.c arm_depthwise_separable_conv_HWC_q7.c arm_depthwise_separable_conv_HWC_q7_nonsquare.c arm_nn_depthwise_conv_s8_core.c arm_nn_mat_mult_kernel_q7_q15.c arm_nn_mat_mult_kernel_q7_q15_reordered.c arm_nn_mat_mult_kernel_s8_s16.c arm_nn_mat_mult_kernel_s8_s16_reordered.c arm_nn_mat_mult_s8.c
    ./tensorflow/lite/micro/tools/make/downloads/cmsis/CMSIS/NN/Source/FullyConnectedFunctions/: arm_fully_connected_mat_q7_vec_q15.c arm_fully_connected_mat_q7_vec_q15_opt.c arm_fully_connected_q7.c arm_fully_connected_q7_opt.c arm_fully_connected_q15.c arm_fully_connected_q15_opt.c arm_fully_connected_s8.c
    ./tensorflow/lite/micro/tools/make/downloads/cmsis/CMSIS/NN/Source/NNSupportFunctions/: arm_nn_accumulate_q7_to_q15.c arm_nn_add_q7.c arm_nn_depthwise_conv_nt_t_padded_s8.c arm_nn_depthwise_conv_nt_t_s8.c arm_nn_mat_mul_core_1x_s8.c arm_nn_mat_mul_core_4x_s8.c arm_nn_mat_mult_nt_t_s8.c arm_nn_mult_q7.c arm_nn_mult_q15.c arm_nn_vec_mat_mult_t_s8.c arm_nntables.c arm_q7_to_q15_no_shift.c arm_q7_to_q15_reordered_no_shift.c arm_q7_to_q15_reordered_with_offset.c arm_q7_to_q15_with_offset.c
    ./tensorflow/lite/micro/tools/make/downloads/cmsis/CMSIS/NN/Source/PoolingFunctions/: arm_avgpool_s8.c arm_max_pool_s8.c arm_pool_q7_HWC.c
    ./tensorflow/lite/micro/tools/make/downloads/cmsis/CMSIS/NN/Source/ReshapeFunctions/: arm_reshape_s8.c
    ./tensorflow/lite/micro/tools/make/downloads/cmsis/CMSIS/NN/Source/SoftmaxFunctions/: arm_softmax_q7.c arm_softmax_q15.c arm_softmax_s8.c arm_softmax_u8.c arm_softmax_with_batch_q7.c
  group tensorflow/lite/micro/example/speech
    ./tensorflow/lite/micro/examples/micro_speech/: micro_speech.cc
    ./tensorflow/lite/micro/examples/micro_speech/micro_features/: model.cc no_micro_features_data.cc yes_micro_features_data.cc
software components: CMSIS:CORE 5.4.0
